# Keil uVision project LED Blinking using 8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: LED Blinking using 8051
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LED blinking using 8051.c
